# KOMPAS-3D assembly (Сборка лампочка.a3d)

Referenced files in D:\диск работа\Работа\твой стартап\Тексты на сайт\Чертежи\Лампочка\: Корпус.m3d, Цоколь.m3d